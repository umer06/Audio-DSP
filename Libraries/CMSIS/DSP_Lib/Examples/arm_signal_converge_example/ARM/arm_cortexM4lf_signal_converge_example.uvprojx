# Keil uVision project arm_cortexM4lf_signal_converge_example.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4lf_signal_converge_example
  c flags: Optim=3 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\..\..\..\Include;..\..\Common\Include;..\..\..\..\..\Device\ARM\ARMCM4\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../: arm_signal_converge_data.c arm_signal_converge_example_f32.c
    ../../Common/Source/: math_helper.c
  group CMSIS Device
    ../: system_ARMCM4.c
    ./: startup_ARMCM4.s
  group CMSIS DSP_Library
    ../../../../Lib/ARM/: arm_cortexM4lf_math.lib
